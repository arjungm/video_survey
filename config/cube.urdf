Commit message: made smaller robot, fixed bfs 3d, added using bfs path for feature comp

File: config/cube.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link base_link: geometry visual box size=0.02 0.02 0.02
